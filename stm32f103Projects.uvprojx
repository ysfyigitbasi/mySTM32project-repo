# Keil uVision project stm32f103Projects.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103Projects
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Application
    ./STM32F103C8X_projects/: main.c
  group User Libraries
    ./STM32F103C8X_projects/: _HAL_GPIO.h _HAL_GPIO.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
