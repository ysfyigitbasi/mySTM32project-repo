# Keil uVision project timer_test_project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: timer_test_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Source
    ./: main.c
  group User Lib
    ./: _TIM_CONFIG.h _TIM_CONFIG.c _HAL_GPIO.c _HAL_GPIO.h _UART.h _UART.c _I2C.h _I2C.c _BMP388.h _BMP388.c bno055.c test.c bno055.h bno055_stm32.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
